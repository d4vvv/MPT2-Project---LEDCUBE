# Keil uVision project LedCube.uvprojx, settings and files
target MKL05Z32 (6140000::V6.14::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: int_tutor
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c tpm.c sct.h sct.c SysTick.c uart0.c tetris.c tetris.h snake.c snake.h demo.h demo.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
